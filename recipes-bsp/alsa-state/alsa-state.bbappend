FILESEXTRAPATHS_prepend_variscite := "${THISDIR}/${PN}:"
