FILESEXTRAPATHS_prepend_variscite := "${THISDIR}/files:"
SRC_URI_append_variscite = " file://0001-psplash-Change-colors-for-the-Variscite-Yocto-logo.patch"
