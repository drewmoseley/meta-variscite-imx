# Add master brach is deleted and replaced by main branch
SRC_URI_variscite = "git://salsa.debian.org/iso-codes-team/iso-codes.git;protocol=http;branch=main"

